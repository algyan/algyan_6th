# Repository algyan/algyan_6th

File readme.md:

# ALGYAN 6th
  This Repository is "IoT ALGYAN 6th" event novelty board info.

  Top  
  |  
  +- board_info : board design information (ex.gerber data, schematics etc.)  
  |  
  +- Howto_Soldering : Instructions for soldering parts  
  |  
  +- HwTestApps :

## EAGLE design board_Info/algyan-6th-03.brd

File board_Info/readme.md (part):

[board_design]: img/algyan-6th.png
[board_sch]: img/algyan-6th-sch.png

# Board Info

## <a name="S0">0. Index</a>

* [1. Board Design](#S1)
* [2. Schematics](#S2)
* [3. Body of Materials](#S3)
  * [3-1. Parts List](#S3-1)
  * [3-2. Parts set A(お手軽)](#S3-2)
  * [3-3. Parts set B(手作りFULL)](#S3-3)

---

## <a name="S1">1. Board Design</a>

This board is designed by **Designed by EAGLE 9.6.2**.

* File(brd) : **algyan-6th-03.brd**
* File(gerber) : **algyan-6th-03_2021-04-03.zip**
* Image(png) : **img/algyan-6th.png**
    ![Board][board_design]

[↑ Back to Index](#S0)

---

## <a name="S2">2. Schematics</a>

* File(sch) : **algyan-6th-03.sch**
* File(pdf) : **algyan-6th-03.pdf**
* Image(png) : **img/algyan-6th-sch.png**  
    ![Board_sch][board_sch]

[↑ Back to Index](#S0)

---

## <a name="S3">3. Body of Materials</a>

### <a name="S3-1">3-1. Parts list</a>
|No.|部品名|種類|型番・値|個数|オンライン販売URL|
|:-:|:---:|:--:|:-----:|:----:|:---------------|
|1-1|ESP32-WROOM-32|U1||0～1|https://akizukidenshi.com/catalog/g/gM-11647/|
|1-2|ESP32-WROOM-32D|U1||0～1|https://akizukidenshi.com/catalog/g/gM-13318/|
|1-3|ESP32-WROOM-32E(16MB)|U1||0～1|https://akizukidenshi.com/catalog/g/gM-15675/|
|2|三端子レギュレータ|U2|NJM2845DL1|1|https://akizukidenshi.com/catalog/g/gI-11299/|
|3|USBシリアルIC|U3|FT231XS-R|1|https://akizukidenshi.com/catalog/g/gI-06713/|
|4|モータードライバーモジュール|U4|DRV8835|1|https://akizukidenshi.com/catalog/g/gK-09848/|
|5-1|ESP32-DevkitC|U5||1|https://akizukidenshi.com/catalog/g/gM-11819/|
|5-2|ESP32-DevKitC-32D|U5||1|https://akizukidenshi.com/catalog/g/gM-13628/|
|5-3|ESP32-DevKitC-32E(4MB)|U5||1|https://akizukidenshi.com/catalog/g/gM-15673/|
|6|チップ抵抗(2012)|R1、R2、R6、R7、R8、R9、R14、R16|10kΩ|2～8|https://www.sengoku.co.jp/mod/sgk_cart/detail.php?code=EEHD-57CE|
|7|チップ抵抗(2012)|R3、R4、R5、R10、R11、R12|100～1kΩ|3～6|https://www.sengoku.co.jp/mod/sgk_cart/search.php?cid=3329|
|8|チップ抵抗(2012)|R13、R15|5.1k/10kΩ|0、2|https://www.sengoku.co.jp/mod/sgk_cart/detail.php?code=EEHD-57C8<br>https://www.sengoku.co.jp/mod/sgk_cart/detail.php?code=EEHD-57CE|
|9|チップコンデンサ(3216)|C1、C2|22uF|2|https://akizukidenshi.com/catalog/g/gP-06038/|
|10|チップコンデンサ(2012)|C3、C5、C12|0.1uF|3|https://akizukidenshi.com/catalog/g/gP-13372/|
|11|チップコンデンサ(1608)|C4、C6、C7|0.01uF|3|https://akizukidenshi.com/catalog/g/gP-13387/|
|12|チップコンデンサ(3216)|C8、C9、C10、C11|0.1～22uF|0～4|https://akizukidenshi.com/catalog/c/c3216/<br>https://akizukidenshi.com/catalog/g/gP-06038/ (22uF)|
|13-1|チップダイオード|D1|RB751V40TE17|0～1|https://www.marutsu.co.jp/pc/i/2182237/|
|13-2|チップダイオード|D1|RB520S|0～1|https://akizukidenshi.com/catalog/g/gI-05566/|
|14|チップトランジスタ|T1、T2|2SC2712|2|https://akizukidenshi.com/catalog/g/gI-00761/|
|15-1|チップLED(赤色)|PWR、TXD、RXD、LED1、LED2、LED3|OSR50805C1C|0～6|https://akizukidenshi.com/catalog/g/gI-06419/|
|15-2|チップLED(緑色)|PWR、TXD、RXD、LED1、LED2、LED3|OSG50805C1C|0～6|https://akizukidenshi.com/catalog/g/gI-06423/|
|15-3|チップLED(オレンジ色)|PWR、TXD、RXD、LED1、LED2、LED3|OSO50805C1C|0～6|https://akizukidenshi.com/catalog/g/gI-06422/|
|15-4|チップLED(白色)|PWR、TXD、RXD、LED1、LED2、LED3|OSW50805C1C|0～6|https://akizukidenshi.com/catalog/g/gI-06425/|
|15-5|チップLED(青色)|PWR、TXD、RXD、LED1、LED2、LED3|OSB50805C1C|0～6|https://akizukidenshi.com/catalog/g/gI-06424/|
|15-6|チップLED(黄緑色)|PWR、TXD、RXD、LED1、LED2、LED3|OSG80805C1C|0～6|https://akizukidenshi.com/catalog/g/gI-06421/|
|15-7|チップLED(黄色)|PWR、TXD、RXD、LED1、LED2、LED3|OSY50805C1C|0～6|https://akizukidenshi.com/catalog/g/gI-06420/|
|16|フルカラーRGB LED|LED4|KPF-3236SURKMGKPBC|0～1|https://akizukidenshi.com/catalog/g/gI-12726/|
|17|チップタクトSW|SW1、SW2、SW3|TVAF06-A020B|3|https://akizukidenshi.com/catalog/g/gP-14888/|
|18|CdSセル|CDS1|GL5528(GL55xxシリーズ)|1|https://akizukidenshi.com/catalog/goods/search.aspx?search=x&keyword=GL55<br>https://akizukidenshi.com/catalog/g/gI-05859/|
|19|電子ブザー|BZ1|UGCM1205XP|1|https://akizukidenshi.com/catalog/g/gP-09800/|
|20|ピンヘッダ(40pin)|CN1、CN2、CN3、CN9||2、2、3、4pin|https://akizukidenshi.com/catalog/g/gC-00167/|
|21|microUSBコネクタ|CN4USB|ZX62-B-5PA(33)|1|https://akizukidenshi.com/catalog/g/gC-11183/|
|22|Groveコネクタ(I2C)|CN5、CN6、CN7、CN8|Female Header (4-pin/ 2mm)|4|https://www.sengoku.co.jp/mod/sgk_cart/detail.php?code=EEHD-4KKK|
|23|L型ピンヘッダ4Pin|CN10||4pin|https://akizukidenshi.com/catalog/g/gC-01627/|
|24|USB Type-CコネクタDIP化キット|CN11USB|AE-USB2.0-TYPE-C-5077R|0、1|https://akizukidenshi.com/catalog/g/gK-15426/|
|25|ピンヘッダ(40pin)|JP1、JP2||19、19pin|https://akizukidenshi.com/catalog/g/gC-00167/|
|26|シングルピンソケット (低メス)|U4、U5用ソケット|2212S-20SG-36|6、6、19、19pin|https://akizukidenshi.com/catalog/g/gC-03138/|

[↑ Back to Index](#S0)

---

### <a name="S3-2">3-2. Parts set A(お手軽)</a>
セット部品は(株)若松通商でオンライン購入可能です。  
  * https://wakamatsu.co.jp/biz/products/detail.php?product_id=38310051

|No.|部品名|種類|型番・値|個数|オンライン販売URL|
|:-:|:---:|:--:|:-----:|:----:|:---------------|
|5-3|ESP32-DevKitC-32E(4MB)|U5||1|https://akizukidenshi.com/catalog/g/gM-15673/|
|6|チップ抵抗(2012)|R8、R9|10kΩ|2|https://www.sengoku.co.jp/mod/sgk_cart/detail.php?code=EEHD-57CE|
|7|チップ抵抗(2012)|R10、R11、R12|220Ω|3|https://www.sengoku.co.jp/mod/sgk_cart/search.php?cid=3329|
|13-1|チップダイオード|D1|RB751V40TE17|0、1|https://www.marutsu.co.jp/pc/i/2182237/|
|13-2|チップダイオード|D1|RB520S|0、1|https://akizukidenshi.com/catalog/g/gI-05566/|
|16|フルカラーRGB LED|LED4|KPF-3236SURKMGKPBC|1|https://akizukidenshi.com/catalog/g/gI-12726/|
|17|チップタクトSW|SW3|TVAF06-A020B|1|https://akizukidenshi.com/catalog/g/gP-14888/|
|18|CdSセル|CDS1|GL5528(GL55xxシリーズ)|1|https://akizukidenshi.com/catalog/goods/search.aspx?search=x&keyword=GL55<br>https://akizukidenshi.com/catalog/g/gI-05859/|
|19|電子ブザー|BZ1|UGCM1205XP|1|https://akizukidenshi.com/catalog/g/gP-09800/|
|20|ピンヘッダ(40pin)|CN1、CN2、CN3、CN9||2、2、3、4pin|https://akizukidenshi.com/catalog/g/gC-00167/|
|22|Groveコネクタ(I2C)|CN5、CN6、CN7、CN8|Female Header (4-pin/ 2mm)|4|https://www.sengoku.co.jp/mod/sgk_cart/detail.php?code=EEHD-4KKK|
|25|ピンヘッダ(40pin)|JP1、JP2||19、19pin|https://akizukidenshi.com/catalog/g/gC-00167/|
|26|シングルピンソケット (低メス)(20pin)|U5|2212S-20SG-36|19、19pin|https://akizukidenshi.com/catalog/g/gC-00167/|

[↑ Back to Index](#S0)

---

### <a name="S3-3">3-3. Parts set B(手作りFULL)</a>
セット部品は(株)若松通商でオンライン購入可能です。  
  * https://wakamatsu.co.jp/biz/products/detail.php?product_id=38310052

|No.|部品名|種類|型番・値|個数|オンライン販売URL|
|:-:|:---:|:--:|:-----:|:----:|:---------------|
|1-2|ESP32-WROOM-32D|U1||0、1|https://akizukidenshi.com/catalog/g/gM-13318/|
|1-3|ESP32-WROOM-32E(16MB)|U1||0、1|https://akizukidenshi.com/catalog/g/gM-15675/|
|2|三端子レギュレータ|U2|NJM2845DL1|1|https://akizukidenshi.com/catalog/g/gI-11299/|
|3|USBシリアルIC|U3|FT231XS-R|1|https://akizukidenshi.com/catalog/g/gI-06713/|
|6|チップ抵抗(2012)|R1、R2、R6、R7、R8、R9、R14、R16|10kΩ|8|https://www.sengoku.co.jp/mod/sgk_cart/detail.php?code=EEHD-57CE|
|7|チップ抵抗(2012)|R3、R4、R5、R10、R11、R12|220Ω|6|https://www.sengoku.co.jp/mod/sgk_cart/search.php?cid=3329|
|8|チップ抵抗(2012)|R13、R15|10kΩ|2|https://www.sengoku.co.jp/mod/sgk_cart/detail.php?code=EEHD-57C8<br>https://www.sengoku.co.jp/mod/sgk_cart/detail.php?code=EEHD-57CE|
|9|チップコンデンサ(3216)|C1、C2|22uF|2|https://akizukidenshi.com/catalog/g/gP-06038/|
|10|チップコンデンサ(1608)|C3、C5、C12|0.1uF|3|https://akizukidenshi.com/catalog/g/gP-13372/|
|11|チップコンデンサ(1608)|C4、C6、C7|0.01uF|3|https://akizukidenshi.com/catalog/g/gP-13387/|
|13-1|チップダイオード|D1|RB751V40TE17|0～1|https://www.marutsu.co.jp/pc/i/2182237/|
|13-2|チップダイオード|D1|RB520S|0～1|https://akizukidenshi.com/catalog/g/gI-05566/|
|14|チップトランジスタ|T1、T2|2SC2712|2|https://akizukidenshi.com/catalog/g/gI-00761/|
|15-1|チップLED(赤色)|PWR、TXD、RXD、LED1、LED2、LED3|OSR50805C1C|2|https://akizukidenshi.com/catalog/g/gI-06419/|
|15-2|チップLED(緑色)|PWR、TXD、RXD、LED1、LED2、LED3|OSG50805C1C|2|https://akizukidenshi.com/catalog/g/gI-06423/|
|15-7|チップLED(黄色)|PWR、TXD、RXD、LED1、LED2、LED3|OSY50805C1C|2|https://akizukidenshi.com/catalog/g/gI-06420/|
|16|フルカラーRGB LED|LED4|KPF-3236SURKMGKPBC|1|https://akizukidenshi.com/catalog/g/gI-12726/|
|17|チップタクトSW|SW1、SW2、SW3|TVAF06-A020B|3|https://akizukidenshi.com/catalog/g/gP-14888/|

Parts:
BZ1: UGCM1205XP
C1, C2: 22uF; C3216
C3, C5, C12: 0.1uF; C2012
C4, C6, C7: 0.01uF; C1608
C8, C9, C10, C11: (0.1-22uF); C3216
CDS1: GL5528
CN1, CN9: PINHD-1X2; 1X02
CN2: PINHD-1X4; 1X04
CN3: PINHD-1X3; 1X03
CN4USB: ZX62-B-5PA(33); HRS_ZX62-B-5PA(33)
CN5: I2C; HW4-2.0
CN6: I2C/UART2; HW4-2.0
CN7: DIO(18/19); HW4-2.0
CN8: DIO(32/33); HW4-2.0
CN10: PINHD-1X4/90; 1X04/90
CN11USB: AE-USB20-TYPE-C-5077R
D1: RB751S; SOD-523
JP1, JP2: PINHD-1X19; 1X19
LED1, LED2, LED3: LEDCHIPLED_0805; CHIPLED_0805
LED4: KPF-3236SURKMGKPBC
PWR: LEDCHIPLED_0805; CHIPLED_0805
R1, R2, R6, R7, R8, R9: 10k; R2012
R3, R4, R5, R10, R11, R12: 1k; R2012
R13, R15: 5.1k/(10k); R2012
R14, R16: (10k); R2012
RXD: LEDCHIPLED_0805; CHIPLED_0805
SJ1, SJ2, SJ3: SJ2W; SJ_2
SW1, SW2, SW3: TVAF06-A020B
T1, T2: 2SC2712; SOT23-BEC
TXD: LEDCHIPLED_0805; CHIPLED_0805
U1: ESP-WROOM-32
U2: NJM2845DL1; D-PAK_TO252AA
U3: FT231XS-R; SOP64P599X175-20N
U4: DRV8835DIP
U5: ESP32-DEVKITC-32D; MODULE_ESP32-DEVKITC-32D

Connections:
+3V3: C2.1, C5.1, C6.1, C11.1, C12.1, CDS1.1, CN5.3, CN6.3, CN7.3, CN8.3, CN10.1, D1.C, JP1.1, PWR.A, R6.2, R7.2, RXD.A, SW3.2 (S), TXD.A, U1.2 (3V3), U2.3 (OUT), U3.3 (VCCIO), U3.13 (3V3OUT), U3.14 (RESET#), U3.15 (VCC), U4.VCC, U5.1 (3V3)
+5V: C1.1, C3.1, C4.1, CN1.1, CN3.2, CN4USB.1 (VBUS), CN11USB.VBUS, JP1.19, SJ3.1, U2.1 (IN), U5.19 (EXT_5V)
CBUS1: R5.1, U3.17 (CBUS1)
CBUS2: R4.1, U3.10 (CBUS2)
CLK: JP2.19, U1.20 (CLK), U5.38 (CLK)
CMD: JP1.18, U1.19 (CMD), U5.18 (CMD)
DTR: R1.1, T2.E, U3.1 (DTR#)
EN: C7.1, JP1.2, R6.1, SW1.2 (S), T1.C, U1.3 (EN), U5.2 (EN)
GND: BZ1.P$2 (2), C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C10.2, C11.2, C12.2, CN1.2, CN3.3, CN4USB.5 (GND), CN4USB.SH1 (SHIELD), CN4USB.SH2 (SHIELD), CN4USB.SH3 (SHIELD), CN4USB.SH4 (SHIELD), CN4USB.SH5 (SHIELD), CN4USB.SH6 (SHIELD), CN5.4, CN6.4, CN7.4, CN8.4, CN9.2, CN10.2, CN11USB.GND1, CN11USB.GND2, JP1.14, JP2.1, JP2.7, R3.1, R8.1, R9.1, R10.1, R11.1, R12.1, R13.1, R14.1, R15.1, R16.1, SW1.1, SW2.1, U1.1 (GND), U1.15 (GND), U1.38 (GND), U1.GND, U2.4 (GND), U3.6 (GND1), U3.16 (GND2), U4.GND, U4.MODE, U5.14 (GND1), U5.20 (GND3), U5.26 (GND2)
IO0: JP2.14, R7.1, SW2.2 (S), T2.C, U1.25 (IO0), U5.33 (IO0)
IO2: JP2.15, U1.24 (IO2), U5.34 (IO2)
IO4: JP2.13, U1.26 (IO4), U4.AIN1, U5.32 (IO4)
IO5: JP2.10, U1.29 (IO5), U5.29 (IO5)
IO12: JP1.13, LED1.A, LED4.4 (RA), U1.14 (IO12), U5.13 (IO12)
IO13: CN3.1, JP1.15, U1.16 (IO13), U5.15 (IO13)
IO14: BZ1.P$1 (1), D1.A, JP1.12, U1.13 (IO14), U5.12 (IO14)
IO15: JP2.16, LED2.A, LED4.5 (GA), U1.23 (IO15), U5.35 (IO15)
IO16: JP2.12, SJ1.1, U1.27 (IO16/RXD2), U5.31 (IO16)
IO17: JP2.11, SJ2.1, U1.28 (IO17/TXD2), U5.30 (IO17)
IO18: CN7.1, JP2.9, U1.30 (IO18), U5.28 (IO18)
IO19: CN7.2, JP2.8, U1.31 (IO19), U5.27 (IO19)
IO23: JP2.2, LED3.A, LED4.6 (BA), U1.37 (IO23), U5.21 (IO23)
IO25: JP1.9, U1.10 (IO25), U4.BIN2, U5.9 (IO25)
IO26: JP1.10, U1.11 (IO26), U4.AIN2, U5.10 (IO26)
IO27: JP1.11, U1.12 (IO27), U4.BIN1, U5.11 (IO27)
IO32: CN8.1, JP1.7, U1.8 (IO32), U5.7 (IO32)
IO33: CN8.2, JP1.8, U1.9 (IO33), U5.8 (IO33)
IO34: CDS1.2, JP1.5, R9.2, U1.6 (IO34), U5.5 (IO34)
IO35: JP1.6, R8.2, SW3.1, U1.7 (IO35), U5.6 (IO35)
unnamed: R1.2, T1.B
unnamed: R2.2, T2.B
unnamed: LED1.C, LED4.1 (RC), R10.2
unnamed: C8.1, CN2.1, U4.AOUT1
unnamed: C8.2, CN2.2, U4.AOUT2
unnamed: C9.1, CN2.3, U4.BOUT1
unnamed: C9.2, CN2.4, U4.BOUT2
unnamed: LED2.C, LED4.2 (GC), R11.2
unnamed: LED3.C, LED4.3 (BC), R12.2
unnamed: CN6.2, SJ2.2
unnamed: CN6.1, SJ1.2
unnamed: C10.1, SJ3.2, U4.VM
unnamed: CN11USB.CC1, R13.2, R14.2
unnamed: CN11USB.CC2, R15.2, R16.2
unnamed: CN4USB.2 (D-), CN11USB.D-, U3.12 (USBDM)
unnamed: CN4USB.3 (D+), CN11USB.D+, U3.11 (USBDP)
unnamed: PWR.C, R3.2
unnamed: R5.2, RXD.C
RTS: R2.1, T1.E, U3.2 (RTS#)
RXD0: JP2.5, U1.34 (RXD0), U3.20 (TXD), U5.24 (RXD0)
SCL: CN5.1, CN10.3, JP2.3, SJ1.3, U1.36 (IO22), U5.22 (IO22)
SD0: JP2.18, U1.21 (SD0), U5.37 (SD0)
SD1: JP2.17, U1.22 (SD1), U5.36 (SD1)
SD2: JP1.16, U1.17 (SD2), U5.16 (SD2)
SD3: JP1.17, U1.18 (SD3), U5.17 (SD3)
SDA: CN5.2, CN10.4, JP2.6, SJ2.3, U1.33 (IO21), U5.25 (IO21)
SENSOR_VN: JP1.4, U1.5 (SENSOR_VN), U5.4 (SENSOR_VN)
SENSOR_VP: JP1.3, U1.4 (SENSOR_VP), U5.3 (SENSOR_VP)
TTXD: R4.2, TXD.C
TXD0: JP2.4, U1.35 (TXD0), U3.4 (RXD), U5.23 (TXD0)
VEE: CN9.1, SJ3.3

Notes on the sheet:
ESP32-DevKitC module
ESP32-DevKitC module互換回路
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
Board: 2 copper layers, 56.0 x 85.0 mm, 64 parts (4 on the bottom side), 60 nets.

## Commit log

2021-06-30 first comit
2021-06-30 add board_info, Howto_Solderring(Chapter of preperation)
2021-07-03 Update Howto Soldering
